options:
  parameters:
    generate_options: qt_gui
    id: oposec_sdr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e3
    stop: 3e9
    value: 433e6
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/comando_8M_433M.raw
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_gain
    freq0: frequency
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
