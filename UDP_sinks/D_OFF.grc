options:
  parameters:
    generate_options: no_gui
    id: A_ON
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../samples/cap_8M_433M_D_OFF.raw
    repeat: 'True'
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2008'
    send_eof: 'False'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
